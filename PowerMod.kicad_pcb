# Repository GreekSummer/nanoka-powermod

File README.md:

# Nanoka DC-DC Power Module

This was the first version of Nanoka's power module that adapts 6V-30V to 5V, which the board needs to work. It's based on a simple low-dropout regulator. These resisitive-type regulators don't do switching to step down voltage so they're relatively noise free, which is important for audio circuits. They also have noise filtering properties. 

Initially, this was intended to go inside a car (hence the TVS diode) but I soon realized that it's a horrible idea to fit this in a car. It will probably work until a load dump spike kills it. 

Outside of automotive applications however, this is suitable, and it allows you to power the Nanoka audio board from a wide range of DC power supplies. 

None of this is tested, however, and if you build one of these, you do so *at your own responsibility*!

## KiCad design PowerMod.kicad_pcb

Parts:
C1: 1uf; CAPMP3.7X2.8_2.1N_KEM
C2: 330mf; CAP_20SVPK68M
D1: B160-E3; D_SMA
D2: SMBJ36A; DIOM4336X265N
J1, J2: Conn_01x12_Pin; PinHeader_1x12_P1.27mm_Vertical_Modded
U1: L7805; VREG_L7805CDT-TR

Connections:
GNDPWR: C1.2, C2.2, D2.2 (A), J1.1, J1.2, J1.3, J1.4, J1.5, J2.1, J2.2, J2.3, J2.4, J2.5, U1.3 (GND)
IN+: C1.1, D2.1 (K), J1.8, J1.9, J1.10, J1.11, J1.12, U1.1 (IN)
unnamed: D1.2 (A), U1.2 (OUT)
OUT+: C2.1, D1.1 (K), J2.8, J2.9, J2.10, J2.11, J2.12

Board: 2 copper layers, 16.2 x 23.8 mm, 7 parts (0 on the bottom side), 4 nets.

## Commit log

2025-08-03 Add files
2025-08-14 Remove locks
2025-08-14 Fix wrong U1 footprint, improve silkscreen
2025-08-14 Updated TVS diode
2025-08-15 Added more vias to U1 GND pad for stability
2025-08-15 Updated silk screen info
2025-08-15 Updated schematic to be much clearer
2025-08-17 Complete re-design
2025-08-17 Added central IC 3d model
2025-08-17 Embedded symbols and footprints
